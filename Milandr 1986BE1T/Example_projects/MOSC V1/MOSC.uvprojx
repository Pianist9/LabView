# Keil uVision project MOSC.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: MOSC +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Libraries\CMSIS\CM1\CoreSupport;..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\inc;..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\startup;..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\startup\arm;..\..\Libraries\Config;..\..\Libraries\MDR1986BE4_StdPeriph_Driver\inc;..\..\Libraries\MDR1986BE4_StdPeriph_Driver\src
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ../UART2/: Initmcontroller.c Interrapt.c main.c adrpr.h Initmcontroller.h Interrapt.h
software components: Device:Startup 1.5
