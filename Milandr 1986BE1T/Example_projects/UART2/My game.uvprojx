# Keil uVision project My game.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: MOSC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\startup;..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\inc;..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\startup\arm;..\..\Libraries\MDR1986BE4_StdPeriph_Driver\inc;..\..\Libraries\MDR1986BE4_StdPeriph_Driver\src;..\..\Libraries\Config;..\..\Libraries\CMSIS\CM1\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group User
    ./: main.c Interrapt.c Interrapt.h Initmcontroller.h Initmcontroller.c adrpr.h
  group CMCIC
    ../../Libraries/CMSIS/CM1/DeviceSupport/MDR1986VE1T/inc/: MDR1986VE1T.h
    ../../Libraries/CMSIS/CM1/DeviceSupport/MDR1986VE1T/startup/arm/: startup_MDR1986VE1T.s system_MDR1986VE1T.c system_MDR1986VE1T.h
    ../../Libraries/CMSIS/CM1/CoreSupport/: core_cm1.h
    ../../Libraries/Config/: MDR32F9Qx_config.h MDR32F9Qx_board.h
